# Keil uVision project DisplayBoard.uvprojx, settings and files
target STM32F103RCT6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DisplayBoard +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\STM32F10x_FWLib\src;.\USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ./CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_flash.c
  group USER
    ./USER/: adjust.c bitmap.c flash.c config.c init.c irq.c key.c lcd.c timer.c stimer.c led.c ledandkey.c main.c sys485.c txandre.c powamp.c mtx.c mre.c ptx.c pre.c ui_key.c ui_main.c ui_poweramp.c ui_menu.c ui_file.c ui_setting.c task.c
